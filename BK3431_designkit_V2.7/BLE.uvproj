# Keil uVision project BLE.uvproj, settings and files
target BLE (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: BLE +hex
  AfterMake: fromelf.exe  --bin --output=.\obj\output\BLE.bin .\obj\BLE.axf
  c flags: Optim=4 oTime=1 wLevel=2
  c define: PRH_BS_CFG_SELECT_LEVEL=3,RADIO_TYPE = BK3431,BUILD_TYPE = FLASH_BUILD,CHIMERA,__BYTE_ORDER=__LITTLE_ENDIAN,HW_DATA32,HAB_BASE_ADDR=0x0308000,JAL_BASE_ADDR=0x0801600,__USE_INLINES__,_NO_FIX_CHANNEL_TEST_,_NO_VIRTUAL_HOST_,_NOSEND_TO_HOST
  c include: .\core\sys\include;.\hal\prth_chimera\sys\include;.\core\transport\include;.\hal\hw\include;.\core\hw\include;.\core\lc\include;.\hal\prth_chimera\hw\include;.\core\le\include;.\hal\prth_chimera\hcit\include;.\core\lc\lslc\include;.\core\bt\include;.\core\hc\include;.\core\tc\include;.\core\le\include;.\core\lmp\include;.\core\sys\include;.\core\transport\include;.\hal\hw\radio\BK3431\include
  asm define: TOP_OF_MEMORY=0x00403FF0,ADS_TOOLCHAIN_SUPPORTED=1,BOTTOM_OF_RAM_MEMORY=0x400000 SIZE_OF_RAM_MEMORY=0x037e0
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x400000 size 0x4000
  scatter file: .\lnk\flash_map.sct
  link misc: --entry 0
  group HAL
    ./hal/hw/radio/BK3431/: hw_radio.c
    ./hal/prth_chimera/hcit/: hcit_chimera_16550_serial.c
    ./hal/prth_chimera/hw/: BKPeriUnitAPI.c BKSystemAPI.c BKUartAPI.c BKGpioAPI.c
    ./hal/prth_chimera/sys/: sys_hal_config.c sys_init.c sys_irq.c sys_main.c sys_mmi.c sys_power.c sys_boot.s sys_fiq_irq.s
  group CORE
    ./core/bt/: bt_init.c bt_mini_sched.c
    ./core/le/: le_cts_app.c LE_config.c LE_gatt_server.c LE_link_layer_patch.c LE_connection_patch.c
    ./core/sys/: sys_config.c
    ./core/tc/: tc_interface.c tc_cmd_disp.c tc_event_gen.c
    ./core/transport/: tra_uart.c tra_hcit.c tra_queue.c tra_combined.c tra_usb.c
    ./core/lib/: BK3431_LIB.lib
